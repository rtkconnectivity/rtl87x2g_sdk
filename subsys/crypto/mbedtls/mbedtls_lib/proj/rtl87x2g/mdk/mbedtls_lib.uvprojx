# Keil uVision project mbedtls_lib.uvprojx, settings and files
target mbedtls_lib (6170000::V6.17::.\ARMCompiler6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: mbedtls +hex (library)
  AfterMake: after_build_special.bat
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, BUILD_WITH_FTL=1 FTL_POOL=1
  c misc: -Wno-implicit-function-declaration -gdwarf-3
  c include: ..\..\..\inc;..\..\..\inc_int;..\;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\cmsis\Core\Include;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\common;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\nsc;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\os\osif;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\os\freertos;..\..\..\..\..\..\ROMExport\rtl87x2g\inc\os\freertos\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\..\..\..\ROMExport\rtl87x2g\inc;..\..\..\..\..\..\..\include\rtl87x2g;..\..\..\src;..\..\..\..\..\..\..\include\rtl87x2g\nsc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group src
    ../../../src/: test.c aes.c asn1parse.c asn1write.c bignum.c ecdh.c ecdsa.c ecp.c ecp_curves.c hmac_drbg.c md.c md5.c platform_util.c ripemd160.c sha1.c sha256.c sha512.c mbedtls_hw_interface.c user_memory_function.c
